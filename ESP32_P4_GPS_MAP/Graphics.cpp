#include "Graphics.h"

uint8_t frameBuffer[RES_Y][42];

const uint8_t font57[] = {
  0x3e,0x51,0x49,0x45,0x3e,0x00,0x42,0x7f,0x40,0x00,0x42,0x61,0x51,0x49,0x46,0x21,0x41,0x45,0x4b,0x31,
  0x18,0x14,0x12,0x7f,0x10,0x27,0x45,0x45,0x45,0x39,0x3c,0x4a,0x49,0x49,0x30,0x01,0x71,0x09,0x05,0x03,
  0x36,0x49,0x49,0x49,0x36,0x06,0x49,0x49,0x29,0x1e,0x7c,0x12,0x11,0x12,0x7c,0x7f,0x49,0x49,0x49,0x36,
  0x3e,0x41,0x41,0x41,0x22,0x7f,0x41,0x41,0x22,0x1c,0x7f,0x49,0x49,0x49,0x41,0x7f,0x09,0x09,0x09,0x01,
  0x3e,0x41,0x49,0x49,0x7a,0x7f,0x08,0x08,0x08,0x7f,0x00,0x41,0x7f,0x41,0x00,0x20,0x40,0x41,0x3f,0x01,
  0x7f,0x08,0x14,0x22,0x41,0x7f,0x40,0x40,0x40,0x40,0x7f,0x02,0x0c,0x02,0x7f,0x7f,0x04,0x08,0x10,0x7f,
  0x3e,0x41,0x41,0x41,0x3e,0x7f,0x09,0x09,0x09,0x06,0x3e,0x41,0x51,0x21,0x5e,0x7f,0x09,0x19,0x29,0x46,
  0x46,0x49,0x49,0x49,0x31,0x01,0x01,0x7f,0x01,0x01,0x3f,0x40,0x40,0x40,0x3f,0x1f,0x20,0x40,0x20,0x1f,
  0x3f,0x40,0x38,0x40,0x3f,0x63,0x14,0x08,0x14,0x63,0x07,0x08,0x70,0x08,0x07,0x61,0x51,0x49,0x45,0x43,
  0x00,0x00,0x24,0x00,0x00, 0x00,0x00,0x60,0x60,0x00, 0x40,0x40,0x40,0x40,0x40
};

void setPixel(int x, int y, bool b) {
  if (x < 0 || x >= RES_X || y < 0 || y >= RES_Y) return;
  if (b) frameBuffer[y][x >> 3] &= ~(0x01 << (x & 0x07));
  else   frameBuffer[y][x >> 3] |= (0x01 << (x & 0x07));
}

void drawLine(int x0, int y0, int x1, int y1, bool thick) {
  int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1, dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1, err = dx + dy, e2;
  while (true) { 
    setPixel(x0, y0, true); 
    if(thick) { setPixel(x0+1, y0, true); setPixel(x0, y0+1, true); }
    if (x0 == x1 && y0 == y1) break;
    e2 = 2 * err; if (e2 >= dy) { err += dy; x0 += sx; } if (e2 <= dx) { err += dx; y0 += sy; } 
  }
}

void drawRailway(int x0, int y0, int x1, int y1) {
    int offX = (abs(y1 - y0) > abs(x1 - x0)) ? 2 : 0;
    int offY = (offX == 0) ? 2 : 0;
    drawLine(x0 - offX, y0 - offY, x1 - offX, y1 - offY);
    drawLine(x0 + offX, y0 + offY, x1 + offX, y1 + offY);
    float dist = sqrt(pow(x1-x0, 2) + pow(y1-y0, 2));
    for (int i = 0; i < dist; i += 10) {
        float t = (float)i / dist;
        int cx = x0 + t * (x1 - x0);
        int cy = y0 + t * (y1 - y0);
        drawLine(cx - offX, cy - offY, cx + offX, cy + offY);
    }
}

void drawLargeChar(int x, int y, char c, bool inverted) {
  int idx = -1;
  if (c >= '0' && c <= '9') idx = (c - '0') * 5;
  else if (c >= 'A' && c <= 'Z') idx = (c - 'A' + 10) * 5;
  else if (c >= 'a' && c <= 'z') idx = (c - 'a' + 10) * 5;
  else if (c == ':') idx = 36 * 5; else if (c == '.') idx = 37 * 5;
  else if (c == '-' || c == ' ') idx = 38 * 5;
  if (idx == -1) return;
  for (int i = 0; i < 5; i++) {
    uint8_t line = font57[idx + i];
    for (int j = 0; j < 7; j++) {
      if ((line >> j) & 0x01) {
        for(int dx=0; dx<2; dx++) for(int dy=0; dy<2; dy++) setPixel(x+(i*2)+dx, y+(j*2)+dy, !inverted);
      }
    }
  }
}

void drawLargeString(int x, int y, const char* s, bool inverted) {
  while (*s) { drawLargeChar(x, y, *s++, inverted); x += 14; }
}